# Keil uVision project BoardTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: BoardTest +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Keil_v5\C51\INC\STC
  group Source Group 1
    ./: main.c uart.c led.c da.c ad.c key.c ds18b20.c 1602.c 12864.c 24c02.c dot.c ds12c887.c step.c dc_motor.c helm_motor.c relay.c interrupt.c
